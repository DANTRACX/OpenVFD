# Repository DANTRACX/OpenVFD (continued)

## EAGLE design vfd_controller/schematics/vfd_controller.brd (continued)

Parts:
C10, C11, C12, C13: 100n; C025-024X044
IC3: MAX 485 CPA; DIL08
J5, J6, J7, J8: PIN2F061.200; F061.200
OK1, OK2, OK3, OK4: 6N137; DIL08
R3, R4: 330R; 0204/7
R5: 330R; 0207/12
R6, R8, R9: 1k; 0204/5
R7: 330R; 0204/5
X13: JST-XH-03-PIN-LONG-PAD; JST-XH-03-PACKAGE-LONG-PAD

Connections:
485DE: R4.1; also elsewhere on the board
485RX: OK1.6 (VO), R6.1; also elsewhere on the board
485TX: R3.1; also elsewhere on the board
+5V: C10.2, OK1.8 (VCC), OK2.2 (A), OK3.2 (A), OK4.2 (A), R6.2; also elsewhere on the board
GND: C10.1, OK1.5 (GND); also elsewhere on the board
unnamed: IC3.2 (RE/), IC3.3 (DE), OK3.6 (VO), R8.2
unnamed: IC3.1 (RO), R7.2
unnamed: OK1.3 (C), R7.1
unnamed: IC3.4 (DI), OK2.6 (VO), R9.2
unnamed: OK3.3 (C), R4.2
unnamed: OK2.3 (C), R3.2
unnamed: OK4.3 (C), R5.2
unnamed: OK4.5 (GND), X13.3
unnamed: OK4.6 (VO), X13.2
unnamed: OK4.8 (VCC), X13.1
RS458_5V: C11.1, C12.1, C13.1, IC3.8 (VCC), J5.1A, J5.1B, OK1.2 (A), OK2.8 (VCC), OK3.8 (VCC), R8.1, R9.1
RS485_A: IC3.6 (A), J7.1A, J7.1B
RS485_B: IC3.7 (B), J6.1A, J6.1B
RS485_GND: C11.2, C12.2, C13.2, IC3.5 (GND), J8.1A, J8.1B, OK2.5 (GND), OK3.5 (GND)
SW: R5.1; also elsewhere on the board

Parts:
C14, C22, C23, C27: 100n; C025-024X044
C15, C16, C17, C24, C25, C26: 100n; C050-025X075
C18, C19, C20, C21: 10n; C025-024X044
DC2: 5V in, +-5V out; NMA
IC4, IC5, IC6, IC7: HCPL-7840; DIL08
IC8, IC9, IC10, IC11: MPC3201; DIL08
R10, R11, R12, R13, R14, R15, R16, R17: 68R; 0204/5
X14, X15, X16, X17: JST-XH-02-PIN-LONG-PAD; JST-XH-02-PACKAGE-LONG-PAD

Connections:
+5V: C23.2, C24.2, C25.2, C26.2, C27.2, DC2.1 (+VIN), IC4.8 (VDD2), IC5.8 (VDD2), IC6.8 (VDD2), IC7.8 (VDD2), IC8.1, IC8.8, IC9.1, IC9.8, IC10.1, IC10.8, IC11.1, IC11.8; also elsewhere on the board
GND: C23.1, C24.1, C25.1, C26.1, C27.1, DC2.2 (-VIN), IC4.5 (GND2), IC4.6 (VOUT-), IC5.5 (GND2), IC5.6 (VOUT-), IC6.5 (GND2), IC6.6 (VOUT-), IC7.5 (GND2), IC7.6 (VOUT-), IC8.3, IC8.4, IC9.3, IC9.4, IC10.3, IC10.4, IC11.3, IC11.4; also elsewhere on the board
unnamed: R17.2, X17.1
unnamed: R16.2, X17.2
unnamed: R15.2, X16.1
unnamed: R14.2, X16.2
unnamed: R13.2, X15.1
unnamed: C14.2, C15.2, C16.2, C17.2, C22.1, DC2.5 (COM), IC4.4 (GND1), IC5.4 (GND1), IC6.4 (GND1), IC7.4 (GND1)
unnamed: R12.2, X15.2
unnamed: C18.2, IC4.2 (VIN+), R10.1
unnamed: C19.2, IC5.2 (VIN+), R12.1
unnamed: C19.1, IC5.3 (VIN-), R13.1
unnamed: C20.2, IC6.2 (VIN+), R14.1
unnamed: C20.1, IC6.3 (VIN-), R15.1
unnamed: C21.2, IC7.2 (VIN+), R16.1
unnamed: C21.1, IC7.3 (VIN-), R17.1
unnamed: C14.1, C15.1, C16.1, C17.1, C22.2, DC2.6 (+VOUT), IC4.1 (VDD1), IC5.1 (VDD1), IC6.1 (VDD1), IC7.1 (VDD1)
unnamed: C18.1, IC4.3 (VIN-), R11.1
unnamed: IC4.7 (VOUT+), IC8.2
unnamed: IC5.7 (VOUT+), IC9.2
unnamed: IC6.7 (VOUT+), IC10.2
unnamed: IC7.7 (VOUT+), IC11.2
unnamed: R11.2, X14.1
unnamed: R10.2, X14.2
SENS1: IC8.6; also elsewhere on the board
SENS2: IC9.6; also elsewhere on the board
SENS3: IC10.6; also elsewhere on the board
SENS4: IC11.6; also elsewhere on the board
SENSC: IC8.7, IC9.7, IC10.7, IC11.7; also elsewhere on the board
SENSE: IC8.5, IC9.5, IC10.5, IC11.5; also elsewhere on the board

Board: 2 copper layers, 160.0 x 100.0 mm, 90 parts (0 on the bottom side), 76 nets.

Other parts of the board:
U$1: A4L-LOC

File vfd_controller/schematics/partslist.csv:

Qty,Value,Parts,Description,R
6,,"X2, X3, X14, X15, X16, X17",JST XH Connector 2 Pin,JST XH2P ST
3,,"X4, X5, X13",JST XH Connector 2 Pin,JST XH3P ST
7,,"X6, X7, X8, X9, X10, X11, X12",JST XH Connector 2 Pin,JST XH4P ST
4,,"J5, J6, J7, J8","Flachstecker Typ Tyco/Electronics/AMP TAB, FASTON","FS-PW-6,35"
4, ,"J1, J2, J3, J4","Flachstecker Typ Tyco/Electronics/AMP TAB, FASTON","FS-PW-6,35"
4,100n,"C10, C11, C12, C13","CAPACITOR, European symbol",MKS02-63 100N
9,100n,"C1, C3, C7, C8, C9, C14, C22, C23, C27","CAPACITOR, European symbol",MKS02-63 100N
8,100n,"C5, C6, C15, C16, C17, C24, C25, C26","CAPACITOR, European symbol",MKS2-63 100N
1,10k,R1,"RESISTOR, European symbol","METALL 10,0K"
1,10k,R2,"RESISTOR, European symbol","METALL 10,0K"
4,10n,"C18, C19, C20, C21","CAPACITOR, European symbol",MKS02-63 10N
1,"12V in, 5V out",DC1,DC-DC CONVERTER,MEV1S1205SC
3,1k,"R6, R8, R9","RESISTOR, European symbol","METALL 1,00K"
1,1x10,JP3,PIN HEADER,MPE 087-1-010
1,1x4,JP2,PIN HEADER,MPE 087-1-004
1,1x6,JP1,PIN HEADER,MPE 087-1-006
1,20MHz,X1,CRYSTALS CAN NOT GROUNDED,"20,0000-HC49U-S"
2,22p,"C2, C4","CAPACITOR, European symbol",KERKO 22p
1,330R,R7,"RESISTOR, European symbol",METALL 330
2,330R,"R3, R4","RESISTOR, European symbol",METALL 330
1,330R,R5,"RESISTOR, European symbol",METALL 330
1,"5V in, +-5V out",DC2,DC-DC CONVERTER,MEA1D0505SC
8,68R,"R10, R11, R12, R13, R14, R15, R16, R17","RESISTOR, European symbol","METALL 68,0"
4,6N137,"OK1, OK2, OK3, OK4",MOTOROLA OPTO COUPLER,6N 137
1,Atmega1284P,IC1,Dual In Line,ATMEGA 1284-P-PU
1,Attiny861A,IC2,Dual In Line / Socket,ATTINY 861A-PU
4,HCPL-7840,"IC4, IC5, IC6, IC7",Isolation Amplifer,
1,MAX 485 CPA,IC3,"+5V, Fail-Safe, 40Mbps, Profibus RS-485/RS-422 Transceivers",MAX 485 CPA
4,MPC3201,"IC8, IC9, IC10, IC11",Dual In Line / Socket,MPC 3201-CI/P

## EAGLE design vfd_hardware/vfd_dclink/schematics/vfd_dclink.brd

Parts:
C1, C2, C3, C4, C5, C6: BE LXS 120/450; EB25D
C7: 100n; C025-030X050
C8, C10: 0,47µ; C025-030X050
DC1: MEV1S0512SC; NMA
DC_IN+: 3,81/1,4
DC_IN-: 3,81/1,4
DC_OUT+: 3,81/1,4
DC_OUT-: 3,81/1,4
IC1: ACS758; CB-PFF
IC2: HCPL-7840; DIL08
J1: +5V; F061.080
J2: GND; F061.080
J3: USENSE; F061.080
J4: ISENSE; F061.080
R1, R2: R-EU_0204/5; 0204/5
U: 3,81/1,4
V: 3,81/1,4
W: 3,81/1,4

Connections:
+5V: C7.2, C10.1, DC1.1 (+VIN), IC1.1 (VCC), IC2.8 (VDD2), J1.1A, J1.1B
DC_IN+: C1.+, C2.+, C3.+, DC_IN+.1, IC1.IP+, IC1.IP+@2 (IP+), IC1.IP+@3 (IP+), IC1.IP+@4 (IP+), IC1.IP+@5 (IP+), IC1.IP+@6 (IP+), IC1.IP+@7 (IP+), IC1.IP+@8 (IP+), IC1.IP+@9 (IP+), IC1.IP+@10 (IP+), IC1.IP+@11 (IP+), IC1.IP+@12 (IP+), IC1.IP+@13 (IP+), IC1.IP+@14 (IP+), IC1.IP+@15 (IP+), IC1.IP+@16 (IP+), IC1.IP+@17 (IP+), R1.1
DC_IN-: C4.-, C5.-, C6.-, DC_IN-.1, DC_OUT-.1, IC2.3 (VIN-), R2.2
GND: C7.1, C10.2, DC1.2 (-VIN), IC1.2 (GND), IC2.5 (GND2), IC2.6 (VOUT-), J2.1A, J2.1B
GNDI: C8.1, DC1.5 (COM), IC2.4 (GND1)
ISENSE: IC1.3 (VOUT), IC2.7 (VOUT+), J4.1A, J4.1B
unnamed: DC_OUT+.1, IC1.IP-, IC1.IP-@2 (IP-), IC1.IP-@3 (IP-), IC1.IP-@4 (IP-), IC1.IP-@5 (IP-), IC1.IP-@6 (IP-), IC1.IP-@7 (IP-), IC1.IP-@8 (IP-), IC1.IP-@9 (IP-), IC1.IP-@10 (IP-), IC1.IP-@11 (IP-), IC1.IP-@12 (IP-), IC1.IP-@13 (IP-), IC1.IP-@14 (IP-), IC1.IP-@15 (IP-), IC1.IP-@16 (IP-), IC1.IP-@17 (IP-)
unnamed: C8.2, DC1.6 (+VOUT), IC2.1 (VDD1)
unnamed: C1.-, C4.+
unnamed: C2.-, C5.+
unnamed: C3.-, C6.+
unnamed: IC2.2 (VIN+), R1.2, R2.1
USENSE: J3.1A, J3.1B

Notes on the sheet:
CON_DC mit gewindestangen für kabelverbindungen

Board: 2 copper layers, 192.2 x 124.5 mm, 25 parts (1 on the bottom side), 13 nets.

## EAGLE design vfd_igbt_driver/schematics/vfd_igbtdriver_brd_production.brd

Board: 2 copper layers, 159.8 x 100.0 mm, 79 parts (6 on the bottom side), 66 nets.

Parts:
C1, C3, C4, C5, C7, C8, C9, C11, C12, C13, C15, C16, C17, C19, C20, C21, C23, C24: 0,47µ; C050-035X075
C2, C6, C10, C14, C18, C22: 100n; C050-025X075
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: ZD18; DO35Z10
DC1, DC2, DC3, DC4, DC5, DC6: 12V in, +12V -5V out; MGJ2
E$1: A4L-LOC
IC1, IC2, IC3, IC4, IC5, IC6: FOD3120V; DIL08
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12: F061.040
R1, R3, R5, R7, R9, R11: 140R; 0204/7
R2, R4, R6, R8, R10, R12: 15R; 0617/22
X1, X2, X3, X4, X5, X6: JST-XH-04-PIN-LONG-PAD; JST-XH-04-PACKAGE-LONG-PAD

Connections:
0V: C1.2, DC1.2, X3.1
0V1: C5.2, DC2.2, X1.1
0V2: C9.2, DC3.2, X2.1
0V3: C13.2, DC4.2, X4.1
0V4: C17.2, DC5.2, X5.1
0V5: C21.2, DC6.2, X6.1
+12V: C1.1, DC1.1, X3.2
+12V1: C5.1, DC2.1, X1.2
+12V2: C9.1, DC3.1, X2.2
+12V3: C13.1, DC4.1, X4.2
+12V4: C17.1, DC5.1, X5.2
+12V5: C21.1, DC6.1, X6.2
CTRL_5V: R1.2, X3.3
CTRL_5V1: R3.2, X1.3
CTRL_5V2: R5.2, X2.3
CTRL_5V3: R7.2, X4.3
CTRL_5V4: R9.2, X5.3
CTRL_5V5: R11.2, X6.3
CTRL_GND: IC1.3, X3.4
CTRL_GND1: IC2.3, X1.4
CTRL_GND2: IC3.3, X2.4
CTRL_GND3: IC4.3, X4.4
CTRL_GND4: IC5.3, X5.4
CTRL_GND5: IC6.3, X6.4
EMITTER: C3.2, C4.1, D1.C, DC1.6, J5.A1, J5.A2
EMITTER1: C7.2, C8.1, D3.C, DC2.6, J1.A1, J1.A2
EMITTER2: C11.2, C12.1, D5.C, DC3.6, J3.A1, J3.A2
EMITTER3: C15.2, C16.1, D7.C, DC4.6, J7.A1, J7.A2
EMITTER4: C19.2, C20.1, D9.C, DC5.6, J9.A1, J9.A2
EMITTER5: C23.2, C24.1, D11.C, DC6.6, J11.A1, J11.A2
GATE: D2.C, J6.A1, J6.A2, R2.1
GATE1: D4.C, J2.A1, J2.A2, R4.1
GATE2: D6.C, J4.A1, J4.A2, R6.1
GATE3: D8.C, J8.A1, J8.A2, R8.1
GATE4: D10.C, J10.A1, J10.A2, R10.1
GATE5: D12.C, J12.A1, J12.A2, R12.1
unnamed: C2.1, C4.2, DC1.5, IC1.5
unnamed: C2.2, C3.1, DC1.7, IC1.8
unnamed: IC1.6, IC1.7, R2.2
unnamed: IC1.2, R1.1
unnamed: C6.1, C8.2, DC2.5, IC2.5
unnamed: D1.A, D2.A
unnamed: C6.2, C7.1, DC2.7, IC2.8
unnamed: IC2.6, IC2.7, R4.2
unnamed: D3.A, D4.A
unnamed: IC2.2, R3.1
unnamed: C10.1, C12.2, DC3.5, IC3.5
unnamed: C10.2, C11.1, DC3.7, IC3.8
unnamed: IC3.6, IC3.7, R6.2
unnamed: D5.A, D6.A
unnamed: IC3.2, R5.1
unnamed: C14.1, C16.2, DC4.5, IC4.5
unnamed: C14.2, C15.1, DC4.7, IC4.8
unnamed: IC4.6, IC4.7, R8.2
unnamed: D7.A, D8.A
unnamed: IC4.2, R7.1
unnamed: C18.1, C20.2, DC5.5, IC5.5
unnamed: C18.2, C19.1, DC5.7, IC5.8
unnamed: IC5.6, IC5.7, R10.2
unnamed: D9.A, D10.A
unnamed: IC5.2, R9.1
unnamed: C22.1, C24.2, DC6.5, IC6.5
unnamed: C22.2, C23.1, DC6.7, IC6.8
unnamed: IC6.6, IC6.7, R12.2
unnamed: D11.A, D12.A
unnamed: IC6.2, R11.1

## Commit log

2019-04-08 Initial Upload
2019-08-04 Update Folder Structure
2019-08-04 Minor code changes
    Changed register definitions to match module name and allow
    redefinition for other modules.
    Changed pll lock wait loop to use the correct counter
    variable.
2019-08-09 Updated SVPWM API
    Added user accessable functions
    Added automatic frequency setting from register value
    Added more PWM frequency steps
2019-08-10 Fixed some bugs
    Switched back to small lookup table because index
    calculation generates overflow an corrupts output
    signal
    Fixed a bug in loop where sbrs used wrong bit identifier
    Fixed code for angle correction offset calculation
2019-08-11 Fixed a bug in interval calculation
    Extended the lookuptable size to 2604 values so that
    it is now possible to get a 1Hz sine @ 16kHz
    Fixed the bug in the interval calculation which used
    a wrong reference value
    Some code size and speed optimization
2019-10-10 Multiple Changes
    Fixed the footprint bug from the igbt drivers
    Added schematics and pcb for dc-bus
    Added new folders for partial pfc voltage doubling rectifier
    Added schematics for controller
2019-10-17 Update Controller Schematic & PCB
2019-10-20 Updated Schematics
    Updated already finnished schematics with Reichelt (DE) parts attribute
    Finalized the controller board
2019-10-20 Added drill markins to pcb
2019-10-21 Updated Parts List and fix Footprint
    Fixed 12V to 5V DCDC footprint in Controller PCB
    Switched some 100n Capacitor footprints to bigger RM
    Updated Parts List
2019-11-06 Interim commit of svpwm programming
    Added spi interface to svpwm ic
2019-11-06 Multiple Changes
    - Upgraded SVPWM to 0-65535mHz range
    - Finalized SPI Interface
2019-11-07 Updated SVPWM IC
    Removed glitching of Outputs caused by too much spi interrupts
2019-11-08 Added Fault-Protection to SVPWM IC
2019-11-10 Added SPI-SVPWM communication to controller
2019-11-11 Small Bugfixes in SVPWM
    Fixed bug with t0 calculation - removed /2 operation
    Fixed bug with wrong register for phase offset in interface
2019-11-18 Added code to RS232 module
2019-11-19 Multiple Additions
    - Added RS485 code (equal to RS232) with UART0
    - Added SENSE code
    - Switched RS232 interface to UART1
2020-03-30 Added subroutines started coding torque controller subroutine started coding registry subroutine
2020-04-01 Added further subroutines and modules Added a moving-average filter mechanism to the controller Added a timing/scheduling mechanism to controller Updated controller timeout behavior
2020-04-02 Finished Controller programming Completed the programming on the controller, some performance improvements, code cleaning Added code for EEPROM parameter reading and writing Started work on registry
2020-04-03 Updated REGISTRY and defined Adresses Switched serial module to scpi module Started working on scpi module Renamed some REGISTRY entries Defined MODBUS/SCPI Adresses
2020-04-04 Continued work on SCPI Implemented SCPI send and receive routines
2020-04-05 Updates, Bugfixes and much more Updated the SCPI module to a more usable approach, polished the code. Fixed a bug in MEM module: decrement at wrong position led to address mismatch Implemented the U/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
2020-04-05 Started work on SCPI help First try for a SCPI help message
2020-04-08 Multiple changes Changed MEM to save entire struct and added crc16 checksum to detect data faults Changed some register mappings Moved U/f calculation from controller initialization to trigger-by-set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
2020-04-18 Multiple Changes - changed some regiser mapping - added sense offset regisers - switched status register from string to simpler sreg - removed some variables thanks to the new status register - added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
2020-04-19 Added Modbus Code
2020-04-20 Some Modifications - changed some register mappings - added some registers - fixed a bug with rs485 - fixed a bug in modbus register adressing
2020-04-21 Upgraded TIME to more effcient approach
2020-04-28 Some Modbus bugfixing
2020-06-18 Added build documentation and some code testing
    -Added some images from vfd build
    -Found a bug in U and I measurement - still needs to be fixed
    -Added new filtering code
    -Added stencil for power module hole alignment
2020-06-18 Update readme to include image
2020-07-04 Buxfixing and filter testing
    Fixed a bug in RS485+MODBUS where tx injects data to rx due to interface
    topology which leads to error and response data
    Added oversampling technique and median filtering for measurement
    improvement - seems not to work as good as it should
2020-07-17 Updated schematic for controller Designed new PCB for the controller Modularity of controller has been increased I/O board and COM board are now independent of CPU board
2020-07-18 Minor changes to Schematics Changed IGBT-Driver signal-side connector to plugs Updated Schematic Information Field
