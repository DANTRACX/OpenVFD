# Repository DANTRACX/OpenVFD

## EAGLE design vfd_controller/schematics/vfd_controller_io.brd

Parts:
C1, C2, C3, C5, C7, C8: 100n; C050-025X075
C4, C6: 100n; C025-024X044
DC1, DC2: 12V in, 5V out; MEV
IC1, IC2: HCPL-7840; DIL08
IC3, IC4, IC5, IC6: MPC3201; DIL08
X1, X2, X6, X7: JST-XH-02-PIN-LONG-PAD; JST-XH-02-PACKAGE-LONG-PAD
X3, X4: JST-XH-03-PIN-LONG-PAD; JST-XH-03-PACKAGE-LONG-PAD
X5: JST-XH-10-PIN-LONG-PAD; JST-XH-10-PACKAGE-LONG-PAD

Connections:
0V: C4.2, C6.2, DC1.2 (-VIN), DC2.2 (-VIN), X6.2, X7.2
+5V: C3.2, C5.2, C7.2, C8.2, IC1.8 (VDD2), IC2.8 (VDD2), IC3.1, IC3.8, IC4.1, IC4.8, IC5.1, IC5.8, IC6.1, IC6.8, X3.3, X4.3, X5.9
+12V: C4.1, C6.1, DC1.1 (+VIN), DC2.1 (+VIN), X6.1, X7.1
GND: C3.1, C5.1, C7.1, C8.1, IC1.5 (GND2), IC1.6 (VOUT-), IC2.5 (GND2), IC2.6 (VOUT-), IC3.3, IC3.4, IC4.3, IC4.4, IC5.3, IC5.4, IC6.3, IC6.4, X3.1, X4.1, X5.10
IO0: X5.8
IO1: X5.7
IO2: IC6.6, X5.6
IO3: IC5.6, X5.5
IO4: IC3.6, X5.4
IO5: IC4.6, X5.3
IO6: IC3.5, IC4.5, IC5.7, IC6.7, X5.2
IO7: IC3.7, IC4.7, IC5.5, IC6.5, X5.1
unnamed: IC6.2, X4.2
unnamed: IC5.2, X3.2
unnamed: C2.1, DC2.7 (+VOUT), IC2.1 (VDD1)
unnamed: C2.2, DC2.5 (COM), IC2.3 (VIN-), IC2.4 (GND1), X2.1
unnamed: IC1.2 (VIN+), X1.2
unnamed: IC1.7 (VOUT+), IC3.2
unnamed: C1.2, DC1.5 (COM), IC1.3 (VIN-), IC1.4 (GND1), X1.1
unnamed: IC2.2 (VIN+), X2.2
unnamed: C1.1, DC1.7 (+VOUT), IC1.1 (VDD1)
unnamed: IC2.7 (VOUT+), IC4.2

Notes on the sheet:
CLOCK
ENABLE
DATA
VOLTAGE SHUNT
CURRENT SHUNT
TEMPERATURE 1
TEMPERATURE 2
OpenVFD
VFD-Controller I/O Board
(C) 2020 Christoph Klie

Board: 2 copper layers, 52.4 x 100.0 mm, 24 parts (0 on the bottom side), 20 nets.

Other parts of the board:
U$1: A4L-LOC

File vfd_controller/schematics/partslist_io.csv:

Qty,Value,Parts,Description,R
2,,"X1, X2",JST XH Connector 2 Pin,JST XH2P ST
2,100n,"C4, C6","CAPACITOR, European symbol",MKS02-63 100N
6,100n,"C1, C2, C3, C5, C7, C8","CAPACITOR, European symbol",MKS2-63 100N
2,"12V in, 5V out","DC1, DC2",DC-DC CONVERTER,MEV1S1205SC
2,HCPL-7840,"IC1, IC2",Isolation Amplifer,
2,JST-XH-02-PIN-LONG-PAD,"X6, X7",JST XH Connector 2 Pin,JST XH2P ST
2,JST-XH-03-PIN-LONG-PAD,"X3, X4",JST XH Connector 2 Pin,JST XH3P ST
1,JST-XH-10-PIN-LONG-PAD,X5,JST XH Connector 2 Pin,JST XH10P ST
4,MPC3201,"IC3, IC4, IC5, IC6",Dual In Line / Socket,MPC 3201-CI/P

## EAGLE design vfd_igbt_driver/schematics/vfd_igbtdriver.brd

Parts:
C1, C3, C4: 0,47µ; C050-035X075
C2: 100n; C050-025X075
D1, D2: ZD18; DO35Z10
DC1: 12V in, +12V -5V out; MGJ2
IC1: FOD3120V; DIL08
J5, J6: PIN2F061.040; F061.040
R1: 140R; 0204/7
R2: 15R; 0617/22
X3: JST-XH-04-PIN-LONG-PAD; JST-XH-04-PACKAGE-LONG-PAD

Connections:
0V: C1.2, DC1.2 (-VIN), X3.1
+12V: C1.1, DC1.1 (+VIN), X3.2
CTRL_5V: R1.2, X3.3
CTRL_GND: IC1.3, X3.4
EMITTER: C3.2, C4.1, D1.C, DC1.6 (COM), J5.A1, J5.A2
GATE: D2.C, J6.A1, J6.A2, R2.1
unnamed: C2.1, C4.2, DC1.5 (-VOUT), IC1.5
unnamed: C2.2, C3.1, DC1.7 (+VOUT), IC1.8
unnamed: IC1.6, IC1.7, R2.2
unnamed: IC1.2, R1.1
unnamed: D1.A, D2.A

Notes on the sheet:
OpenVFD
VFD IGBT DRIVER
(C) 2020 Christoph Klie

Board: 2 copper layers, 49.8 x 49.8 mm, 14 parts (1 on the bottom side), 11 nets.

Other parts of the board:
U$1: A4L-LOC

File vfd_igbt_driver/schematics/partslist.csv:

Qty,Value,Parts,Description,R
2,,"J5, J6","Flachstecker Typ Tyco/Electronics/AMP TAB, FASTON","FS-P 6,35"
3,"0,47µ","C1, C3, C4","CAPACITOR, European symbol",MKS2-63 470N
1,100n,C2,"CAPACITOR, European symbol",MKS2-63 100N
1,"12V in, +12V -5V out",DC1,DC-DC CONVERTER,MGJ2D121505SC
1,140R,R1,"RESISTOR, European symbol",METALL 140
1,15R,R2,"RESISTOR, European symbol",2W METALL 15
1,FOD3120V,IC1,Dual In Line / Socket,
1,JST-XH-04-PIN-LONG-PAD,X3,JST XH Connector 2 Pin,JST XH2P ST90
2,ZD18,"D1, D2",Z DIODE,ZD18 3W

## EAGLE design vfd_dcbus/schematics/vfd_dcbus.brd

Parts:
C1, C2, C3, C4, C5, C6: 120µ; EB25D
J1, J4, J13, J18, J29: PIN2F061.200; F061.200
J2, J3, J5, J6, J7, J8, J9, J10, J11, J12, J14, J15, J16, J17, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28: PIN2F061.080; F061.080
R1, R4, R7, R9: 10m; R2512
R2, R3, R6, R8: 470k; 0207/5V
R5: 470R; R1206
X1, X2, X3, X4, X5: JST-XH-02-PIN-LONG-PAD; JST-XH-02-PACKAGE-LONG-PAD

Connections:
DC+: C1.+, C2.+, C3.+, J3.1A, J3.1B, J4.1A, J4.1B, J6.1A, J6.1B, J7.1A, J7.1B, J8.1A, J8.1B, J10.1A, J10.1B, J12.1A, J12.1B, R2.2
DC-: C4.-, C5.-, C6.-, J29.1A, J29.1B, R9.1, X5.2
DC--: J20.1A, J20.1B, J22.1A, J22.1B, J23.1A, J23.1B, J24.1A, J24.1B, J26.1A, J26.1B, J28.1A, J28.1B, R8.2, R9.2, X5.1
unnamed: R2.1, R3.1
unnamed: R6.1, R8.1
unnamed: C1.-, C4.+
unnamed: C2.-, C5.+
unnamed: C3.-, C6.+
U_IN: J2.1A, J2.1B, J5.1A, J5.1B, J9.1A, J9.1B, J11.1A, J11.1B, R1.1, X1.2
U_MEAS+: R3.2, R5.1, X4.1
U_MEAS-: R5.2, R6.2, X4.2
U_OUT: J1.1A, J1.1B, R1.2, X1.1
V_IN: J14.1A, J14.1B, J15.1A, J15.1B, J16.1A, J16.1B, J17.1A, J17.1B, R4.1, X2.2
V_OUT: J13.1A, J13.1B, R4.2, X2.1
W_IN: J19.1A, J19.1B, J21.1A, J21.1B, J25.1A, J25.1B, J27.1A, J27.1B, R7.1, X3.1
W_OUT: J18.1A, J18.1B, R7.2, X3.2

Notes on the sheet:
OpenVFD
VFD DC-BUS
(C) 2020 Christoph Klie

Board: 2 copper layers, 160.0 x 100.0 mm, 50 parts (5 on the bottom side), 16 nets.

Other parts of the board:
U$1: A4L-LOC

File vfd_dcbus/schematics/partslist.csv:

Qty,Value,Parts,Description,R
5,,"X1, X2, X3, X4, X5",JST XH Connector 2 Pin,JST XH2P ST
24,,"J2, J3, J5, J6, J7, J8, J9, J10, J11, J12, J14, J15, J16, J17, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28","Flachstecker Typ Tyco/Electronics/AMP TAB, FASTON","VT FS-P 6,35"
5,,"J1, J4, J13, J18, J29","Flachstecker Typ Tyco/Electronics/AMP TAB, FASTON","VT FS-PW 6,35"
4,10m,"R1, R4, R7, R9","RESISTOR, European symbol",ISA SMT R010-1
6,120µ,"C1, C2, C3, C4, C5, C6","POLARIZED CAPACITOR, European symbol",BE LXS 120/450
1,470R,R5,"RESISTOR, European symbol",SPR-1206 470
4,470k,"R2, R3, R6, R8","RESISTOR, European symbol",MPR 470K

## EAGLE design vfd_controller/schematics/vfd_controller_cpu.brd

Parts:
C1, C4, C7, C8, C9: 100n; C025-024X044
C2, C3: 22p; C025-024X044
C5, C6: 100n; C050-025X075
DC1: 12V in, 5V out; MEV
IC1: Atmega1284P; DIL40
IC2: Attiny861A; DIL20
J1, J2: F061.200
JP1: 1x6; 1X06
JP2, JP5: 1x2; 1X02
JP3: 1x4; 1X04
JP4: 1x10; 1X10
R1, R3: 10k; 0207/12
R2: 10k; 0204V
X1: 20MHz; HC49
X2, X3, X6: JST-XH-02-PIN-LONG-PAD; JST-XH-02-PACKAGE-LONG-PAD
X4, X7, X8, X9, X10, X11, X12: JST-XH-04-PIN-LONG-PAD; JST-XH-04-PACKAGE-LONG-PAD
X5: JST-XH-10-PIN-LONG-PAD; JST-XH-10-PACKAGE-LONG-PAD
X13: JST-XH-07-PIN-LONG-PAD; JST-XH-07-PACKAGE-LONG-PAD

Connections:
0V: C4.2, DC1.2 (-VIN), J2.1A, J2.1B, X6.2, X7.4, X8.4, X9.4, X10.4, X11.4, X12.4
232RX: IC1.16, JP3.3, X13.3
232TX: IC1.17, JP3.4, X13.4
485DE: IC1.18, X13.5
485RX: IC1.14, JP3.1, X13.1
485TX: IC1.15, JP3.2, X13.2
+5V: C1.1, C6.1, C8.1, DC1.7 (+VOUT), IC1.10, IC1.30, IC2.5, IC2.15, JP1.5, JP4.5, R1.2, R2.2, R3.1, X4.3, X5.9, X13.6
+12V: C4.1, DC1.1 (+VIN), J1.1A, J1.1B, X6.1, X7.3, X8.3, X9.3, X10.3, X11.3, X12.3
EN_SVPWM: IC1.19, IC2.9, JP4.9
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, DC1.5 (COM), IC1.11, IC1.31, IC2.6, IC2.16, JP1.6, JP2.1, JP4.6, JP5.1, X2.2, X3.2, X4.4, X5.10, X7.2, X8.2, X9.2, X10.2, X11.2, X12.2, X13.7
H1: IC2.1, JP4.1, X7.1
H2: IC2.3, JP4.3, X9.1
H3: IC2.7, JP4.7, X11.1
IO0: IC1.22, X4.2, X5.8
IO1: IC1.23, X4.1, X5.7
IO2: IC1.24, X5.6
IO3: IC1.25, X5.5
IO4: IC1.26, X5.4
IO5: IC1.27, X5.3
IO6: IC1.28, X5.2
IO7: IC1.29, X5.1
L1: IC2.2, JP4.2, X8.1
L2: IC2.4, JP4.4, X10.1
L3: IC2.8, JP4.8, X12.1
MISO: IC1.7, IC2.19, JP1.2
MOSI: IC1.6, IC2.20, JP1.1
unnamed: IC1.1, X3.1
unnamed: C7.1, IC1.32
unnamed: IC1.4, X2.1
unnamed: IC1.2, JP2.2, R1.1
unnamed: C9.1, IC2.10, JP4.10, JP5.2, R3.2
unnamed: C5.1, IC1.9, JP1.4, R2.1
unnamed: C2.1, IC1.12, X1.1
unnamed: C3.1, IC1.13, X1.2
SCK: IC1.8, IC2.18, JP1.3
SS: IC1.5, IC2.17

Notes on the sheet:
AVR-ISP
OPTIONAL I2C
I/O BOARD
I/O 12V
SCPI/MODBUS
OVER 485
DEBUG
OpenVFD
(C) 2020 Christoph Klie
VFD-Controller CPU Board

Board: 2 copper layers, 107.3 x 100.0 mm, 36 parts (0 on the bottom side), 36 nets.

Other parts of the board:
U$1: A4L-LOC

File vfd_controller/schematics/partslist_cpu.csv:

Qty,Value,Parts,Description,R
2,,"X2, X3",JST XH Connector 2 Pin,JST XH2P ST
7,,"X4, X7, X8, X9, X10, X11, X12",JST XH Connector 2 Pin,JST XH4P ST
2, ,"J1, J2","Flachstecker Typ Tyco/Electronics/AMP TAB, FASTON","FS-PW-6,35"
5,100n,"C1, C4, C7, C8, C9","CAPACITOR, European symbol",MKS02-63 100N
2,100n,"C5, C6","CAPACITOR, European symbol",MKS2-63 100N
1,10k,R2,"RESISTOR, European symbol","METALL 10,0K"
2,10k,"R1, R3","RESISTOR, European symbol","METALL 10,0K"
1,"12V in, 5V out",DC1,DC-DC CONVERTER,MEV1S1205SC
1,1x10,JP4,PIN HEADER,MPE 087-1-010
2,1x2,"JP2, JP5",PIN HEADER,MPE 087-1-002
1,1x4,JP3,PIN HEADER,MPE 087-1-004
1,1x6,JP1,PIN HEADER,MPE 087-1-006
1,20MHz,X1,CRYSTALS CAN NOT GROUNDED,"20,0000-HC49U-S"
2,22p,"C2, C3","CAPACITOR, European symbol",KERKO 22p
1,Atmega1284P,IC1,Dual In Line,ATMEGA 1284-P-PU
1,Attiny861A,IC2,Dual In Line / Socket,ATTINY 861A-PU
1,JST-XH-02-PIN-LONG-PAD,X6,JST XH Connector 2 Pin,JST XH2P ST
1,JST-XH-07-PIN-LONG-PAD,X13,JST XH Connector 2 Pin,JST XH7P ST
1,JST-XH-10-PIN-LONG-PAD,X5,JST XH Connector 2 Pin,JST XH10P ST

## EAGLE design vfd_controller/schematics/vfd_controller_com.brd

Parts:
C10, C11, C12, C13: 100n; C025-024X044
IC3: MAX 485 CPA; DIL08
OK1, OK2, OK3: 6N137; DIL08
R3, R4, R7: 330R; 0204/7
R6, R8, R9: 1k; 0204/7
X4: JST-XH-07-PIN-LONG-PAD; JST-XH-07-PACKAGE-LONG-PAD
X22: JST-XH-04-PIN-LONG-PAD; JST-XH-04-PACKAGE-LONG-PAD

Connections:
232RX: X4.3
232TX: X4.4
485DE: R4.1, X4.5
485RX: OK1.6 (VO), R6.1, X4.1
485TX: R3.1, X4.2
+5V: C10.2, OK1.8 (VCC), OK2.2 (A), OK3.2 (A), R6.2, X4.6
GND: C10.1, OK1.5 (GND), X4.7
unnamed: IC3.2 (RE/), IC3.3 (DE), OK3.6 (VO), R8.2
unnamed: IC3.1 (RO), R7.2
unnamed: OK1.3 (C), R7.1
unnamed: IC3.4 (DI), OK2.6 (VO), R9.2
unnamed: OK3.3 (C), R4.2
unnamed: OK2.3 (C), R3.2
RS458_5V: C11.1, C12.1, C13.1, IC3.8 (VCC), OK1.2 (A), OK2.8 (VCC), OK3.8 (VCC), R8.1, R9.1, X22.1
RS485_A: IC3.6 (A), X22.3
RS485_B: IC3.7 (B), X22.2
RS485_GND: C11.2, C12.2, C13.2, IC3.5 (GND), OK2.5 (GND), OK3.5 (GND), X22.4

Board: 2 copper layers, 52.4 x 100.0 mm, 17 parts (0 on the bottom side), 15 nets.

Other parts of the board:
U$1: A4L-LOC

## EAGLE design vfd_controller/schematics/vfd_controller.brd

Parts:
C1, C3, C7, C8, C9: 100n; C025-024X044
C2, C4: 22p; C025-024X044
C5, C6: 100n; C050-025X075
DC1: 12V in, 5V out; MEV
IC1: Atmega1284P; DIL40
IC2: Attiny861A; DIL20
J1, J2, J3, J4: F061.200
JP1: 1x6; 1X06
JP2: 1x4; 1X04
JP3: 1x10; 1X10
R1: 10k; 0204V
R2: 10k; 0207/12
X1: 20MHz; HC49
X2, X3: JST-XH-02-PIN-LONG-PAD; JST-XH-02-PACKAGE-LONG-PAD
X4, X5: JST-XH-03-PIN-LONG-PAD; JST-XH-03-PACKAGE-LONG-PAD
X6, X7, X8, X9, X10, X11, X12: JST-XH-04-PIN-LONG-PAD; JST-XH-04-PACKAGE-LONG-PAD

Connections:
0V: C3.2, DC1.2 (-VIN), J2.1A, J2.1B
0V-TREIBER: J4.1A, J4.1B, X7.4, X8.4, X9.4, X10.4, X11.4, X12.4
232RX: IC1.16, JP2.3
232TX: IC1.17, JP2.4
485DE: IC1.1; also elsewhere on the board
485RX: IC1.14, JP2.1; also elsewhere on the board
485TX: IC1.15, JP2.2; also elsewhere on the board
+5V: C1.1, C6.1, C8.1, DC1.7 (+VOUT), IC1.10, IC1.30, IC2.5, IC2.15, JP1.5, JP3.5, R1.2, R2.1, X4.2, X5.2, X6.3; also elsewhere on the board
+12V: C3.1, DC1.1 (+VIN), J1.1A, J1.1B
+12V-TREIBER: J3.1A, J3.1B, X7.3, X8.3, X9.3, X10.3, X11.3, X12.3
EN_SVPWM: IC1.20, IC2.9, JP3.9
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, DC1.5 (COM), IC1.11, IC1.31, IC2.6, IC2.16, JP1.6, JP3.6, X2.2, X3.2, X4.3, X5.3, X6.4, X7.2, X8.2, X9.2, X10.2, X11.2, X12.2; also elsewhere on the board
H1: IC2.1, JP3.1, X7.1
H2: IC2.3, JP3.3, X9.1
H3: IC2.7, JP3.7, X11.1
L1: IC2.2, JP3.2, X8.1
L2: IC2.4, JP3.4, X10.1
L3: IC2.8, JP3.8, X12.1
MISO: IC1.7, IC2.19, JP1.2
MOSI: IC1.6, IC2.20, JP1.1
unnamed: IC1.23, X6.1
unnamed: IC1.22, X6.2
unnamed: IC1.33, X5.1
unnamed: IC1.34, X4.1
unnamed: C7.1, IC1.32
unnamed: IC1.39, X3.1
unnamed: IC1.40, X2.1
unnamed: C9.1, IC2.10, JP3.10, R2.2
unnamed: C5.1, IC1.9, JP1.4, R1.1
unnamed: C2.1, IC1.12, X1.1
unnamed: C4.1, IC1.13, X1.2
SCK: IC1.8, IC2.18, JP1.3
SENS1: IC1.26; also elsewhere on the board
SENS2: IC1.27; also elsewhere on the board
SENS3: IC1.28; also elsewhere on the board
SENS4: IC1.29; also elsewhere on the board
SENSC: IC1.19; also elsewhere on the board
SENSE: IC1.21; also elsewhere on the board
SS: IC1.5, IC2.17
SW: IC1.18; also elsewhere on the board

Notes on the sheet:
AVR-ISP

Notices in the files:
vfd_controller/schematics/vfd_controller.brd:
(C) 2019 Christoph Klie
